FILESEXTRAPATHS:prepend := "${THISDIR}/files:"

SRC_URI += "file://custom-logo.png"


SPLASH_IMAGES = "file://custom-logo.png;outsuffix=default"

